options:
  parameters:
    generate_options: qt_gui
    id: keyonoffscope
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: decimation_factor
  id: variable
  parameters:
    value: '4'
  states: {}
- name: fsk_deviation_hz
  id: variable
  parameters:
    value: '25000'
  states: {}
- name: low_pass_samp_rate
  id: variable
  parameters:
    value: samp_rate / decimation_factor
  states: {}
- name: lp_freq
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: samples_per_symbol
  id: variable
  parameters:
    value: low_pass_samp_rate/symbol_rate
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: '38400'
  states: {}
- name: tune_freq
  id: variable
  parameters:
    value: '433980000'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: low_pass_samp_rate/(2*math.pi*fsk_deviation_hz)
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.995'
    threshold: '-40'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_correlate_access_code_tag_xx_1
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '10101010101010101010101010101010'
    tagname: PACKET_START
    threshold: '0'
    type: byte
  states: {}
- name: digital_correlate_access_code_tag_xx_2
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '11010011100100011101001110010001'
    tagname: WORDSYNC
    threshold: '0'
    type: byte
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    nfilters: '128'
    osps: '1'
    resamp_type: digital.IR_PFB_NO_MF
    sps: samples_per_symbol
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: ff
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: lp_freq
    decim: decimation_factor
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: lp_freq/5
    win: window.WIN_HAMMING
  states: {}
- name: pdu_add_system_time_0
  id: pdu_add_system_time
  parameters:
    key: pmt.intern("system_time")
  states: {}
- name: pdu_pdu_split_0
  id: pdu_pdu_split
  parameters:
    pass_empty: 'False'
  states: {}
- name: pdu_tags_to_pdu_x_0
  id: pdu_tags_to_pdu_x
  parameters:
    end_tag: EOB
    max_pdu_size: '80'
    rate: symbol_rate
    start_tag: WORDSYNC
    type: b
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: tune_freq
    gain0: '20'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://127.0.0.1:53280
    timeout: '100'
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', digital_symbol_sync_xx_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_quadrature_demod_cf_0, '0']
- [digital_binary_slicer_fb_0, '0', digital_correlate_access_code_tag_xx_1, '0']
- [digital_correlate_access_code_tag_xx_1, '0', digital_correlate_access_code_tag_xx_2, '0']
- [digital_correlate_access_code_tag_xx_2, '0', pdu_tags_to_pdu_x_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [low_pass_filter_0, '0', analog_simple_squelch_cc_0, '0']
- [pdu_add_system_time_0, pdu, blocks_message_debug_0, print]
- [pdu_add_system_time_0, pdu, pdu_pdu_split_0, pdu]
- [pdu_pdu_split_0, vec, zeromq_pub_msg_sink_0, in]
- [pdu_tags_to_pdu_x_0, pdus, pdu_add_system_time_0, pdu]
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
